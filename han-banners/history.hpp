#pragma once
#include "world.hpp"

namespace han {
struct PlaceHistory {
    const char* anchor;
    const char* context;
};
// Ordered by persistent city ID. Anchors are approximate modern locations.
inline constexpr PlaceHistory placeHistory[] = {
    {"今西安西北汉长安城", "长安是西汉旧都，北临渭水。"},
    {"今洛阳以东汉魏故城", "汉末洛阳是旧都，朝廷已迁许。"},
    {"今成都旧城一带", "蜀郡治所，扼成都平原腹地。"},
    {"今陕西汉中旧城一带", "张鲁治下称汉宁郡，215年曹操平定汉中后复称汉中郡。"},
    {"今许昌东南张潘故城", "汉献帝迁许后，朝廷设在这里。"},
    {"今临漳邺城遗址", "曹操平河北后以邺为重镇。"},
    {"今襄阳古城、汉水南岸", "原属南郡。曹操入荆后建襄阳郡，北岸是樊城。"},
    {"今荆州古城一带", "南郡治所，控长江中游。"},
    {"今南京江宁秣陵一带", "212年改建业，重心转至石头城。"},
    {"今九江市柴桑一带", "地处长江与鄱阳湖通道附近。"},
    {"今武汉汉水入江一带", "夏口是江汉水口，城垣有沿革。"},
    {"今河南南阳宛城一带", "南阳郡治所，南接襄阳。"},
    {"今湖北宜昌长江北岸", "东汉属南郡。曹操置临江郡，刘备改宜都郡，孙吴222年改县名西陵。"},
    {"今重庆渝中两江交汇处", "巴郡治所，嘉陵江汇入长江。"},
    {"今四川梓潼县一带", "古蜀道在成都平原以北的节点。"},
    {"今湖南长沙旧城一带", "长沙郡治所，临湘水东岸。"},
    {"今湖南永州零陵区", "东汉零陵郡治，接近潇湘汇流。"},
    {"今湖南常德沅江北岸", "东汉武陵郡治所一带。"},
    {"今湖南郴州旧城一带", "桂阳郡治所，在南岭北侧。"},
    {"今江苏苏州旧城", "吴郡治所，连通太湖水网。"},
    {"今浙江绍兴旧城", "会稽郡治所，孙策曾亲领其郡。"},
    {"今江西南昌旧城一带", "豫章郡治所，处赣水下游。"},
    {"今安徽寿县古城一带", "寿春临淮水，是淮南重镇。"},
    {"今安徽合肥旧城周边", "巢湖与淮河之间的军事要地。"},
    {"今睢宁古邳镇故城", "东汉曾为下邳国治。建安年间改郡，在古泗水沿线。"},
    {"今山东昌乐故址一带", "东汉北海国治所。取昌乐说，另有寿光纪台说。"},
    {"今北京广安门一带", "古蓟一带兼有幽州、广阳记载。"},
    {"今甘肃陇西巩昌一带", "陇西郡县，沿渭水通关中。"},
    {"今甘肃武威凉州一带", "武威郡治所，居河西走廊东段。"},
    {"今广州南越国宫署附近", "南海郡治所，通珠江水网和海路。"},
    {"今四川广元昭化古城", "嘉陵江汇流处，通金牛道。刘备定蜀后改名汉寿。"},
    {"今江苏扬州蜀冈一带", "长江北岸，连通淮南。"},
    {"今广西桂林旧城一带", "始安属零陵郡，北通灵渠。"},
    {"今广西贺街镇东汉城址", "苍梧郡县，沿贺江通西江。"},
    {"今广西梧州桂江口附近", "县治地望有梧州、封开等说。"},
    {"今广东肇庆西江北岸", "苍梧郡县，位于西江走廊。"},
    {"今广西合浦廉州草鞋村", "汉城遗址靠近南流江下游。"},
    {"今广东徐闻二桥汉代港址", "雷州半岛南端，县治取港址附近。"},
    {"今福建福州市区一带", "史书亦作候官，位于闽江下游。"},
    {"今福建建瓯建溪河谷", "建安八年在当地设都尉府。"},
    {"今越南北宁顺成羸娄古城", "交趾郡县。考古地点称 Luy Lau。"},
    {"今越南清化马江附近", "九真郡县，按当地胥浦遗址落点。"},
    {"今越南广平省北部一带", "日南郡属县，城址未定，取区域锚点。"},
    {"今湖北鄂州旧城一带", "孙权在221年迁治，改名武昌。"},
    {"今陕西宝鸡陈仓一带", "汉代城在渭水谷地，接陈仓道。"},
    {"今安徽亳州老城一带", "东汉属沛国，曹操籍贯所在。"},
    {"今山东平原县东南一带", "平原郡县，处黄河以北平原。"},
    {"今四川广汉雒城一带", "广汉郡治所，位于成都平原北侧。"},
    {"今河南濮阳一带", "《演义》第十二回，陈宫设谋，曹操夜入濮阳陷于火攻。"},
    {"今江苏沛县一带", "《演义》第十一回，刘备屯兵小沛，修城安民。"},
    {"今河南中牟一带", "《演义》第三十回，曹操与袁绍相持于官渡，夜袭乌巢。"},
    {"今湖北赤壁市长江南岸", "《演义》第四十九回，周瑜火攻曹军。地图取蒲圻赤壁一说。"},
    {"今重庆奉节白帝城", "《演义》第八十五回写托孤。汉末县名鱼复，222年改永安。"},
    {"今湖北当阳两河镇一带", "《演义》第七十六回，关羽失荆州后败走麦城。"},
    {"今河南荥阳汜水镇一带", "《演义》第五回，刘关张在虎牢关合战吕布。"},
    {"今四川剑阁县剑门关", "《演义》第一百十七回，姜维据守剑阁，魏军改走阴平。"},
    {"今襄阳樊城、汉水北岸", "与襄阳隔汉水相望。219年曹仁守樊，关羽围城。"},
    {"今湖北竹山上庸镇一带", "在堵河谷地。219年申耽归刘备，后曹魏合上庸、房陵、西城为新城郡。"},
    {"今四川绵阳涪江沿岸", "刘璋曾在涪会刘备。刘备自葭萌南下取涪，再围雒。"},
    {"今湖北秭归归州一带", "楚地峡江旧县。孟达由此北攻房陵，刘备东征也曾驻军于此。"},
    {"今安徽潜山梅城一带", "庐江郡皖县。曹操部将朱光屯田于此，214年孙权破城。"},
    {"今安徽裕溪河入江一带", "濡须水通巢湖与长江，孙权筑坞拒曹。口与坞为沿线地标，地图取入江口。"},
    {"今山东淄博临淄齐故城", "东汉齐国治。三国史籍也写作临菑。"},
    {"今甘肃礼县祁山堡一带", "西汉水谷地的陇右据点。228年诸葛亮初出祁山。"},
};
static_assert(std::size(placeHistory)==cityCount);

struct OfficialRecord {
    int city;
    unsigned chapters;
    const char* title;
    const char* details;
    const char* source;
};
// Bits correspond to the autumn 208, spring 214 and autumn 219 starts.
// A near-date or uncertain appointment is labelled as such in the record.
inline constexpr OfficialRecord officials[] = {
    {0,2,"张既 · 京兆尹","曹操西定关中后任命，后迁雍州刺史。","三国志·张既传"},
    {0,4,"张既 · 雍州刺史","平定汉中时已领雍州，后来劝迁氐民入关。","三国志·张既传"},
    {2,3,"刘璋 · 益州牧","208年与214年春，刘璋治成都。","三国志·刘二牧传"},
    {2,4,"刘备 · 益州牧","平蜀后领益州牧，219年称汉中王。","三国志·先主传"},
    {3,3,"张鲁 · 领汉宁太守","在汉中据政，215年后降曹操。","三国志·张鲁传"},
    {3,4,"魏延 · 汉中太守","219年刘备称王后，任魏延镇汉中。","三国志·魏延传"},
    {4,1,"荀彧 · 守尚书令","曹操出征时，荀彧在许处理朝政。","三国志·荀彧传"},
    {4,6,"汉献帝 · 朝廷居许","曹操的魏国以邺为中心，汉廷仍在许。","三国志·武帝纪"},
    {5,1,"曹操 · 丞相","204年取邺，数年后仍以邺为重镇。","三国志·武帝纪"},
    {5,2,"曹操 · 魏公","213年封魏公，魏国以邺为中心。","三国志·武帝纪"},
    {5,4,"曹操 · 魏王","216年进爵魏王，邺是魏国都城。","三国志·武帝纪"},
    {6,4,"吕常 · 将军","219年关羽围吕常于襄阳，曹仁守樊城。","三国志·徐晃传"},
    {7,1,"曹仁 · 屯江陵","曹操平荆州后，曹仁留守江陵以拒周瑜。","三国志·曹仁传"},
    {7,2,"关羽 · 镇守荆州","刘备入蜀期间，关羽负责荆州防务。","三国志·关羽传"},
    {7,4,"糜芳 · 南郡太守","219年糜芳守江陵，后降孙权。","三国志·关羽传"},
    {8,6,"孙权 · 治建业","212年筑石头城，改秣陵为建业。","三国志·吴主传"},
    {8,1,"孙瑜 · 丹杨太守","204年领郡，曾屯溧阳，后徙牛渚。","三国志·宗室传"},
    {9,1,"孙权 · 驻柴桑","赤壁战前，孙权在此接见诸葛亮。","三国志·诸葛亮传"},
    {10,1,"刘琦 · 江夏太守","208年刘琦出任江夏太守，后与刘备会合。","三国志·刘表传"},
    {10,2,"程普 · 曾领江夏太守","先领江夏，曾代周瑜领南郡，后回江夏。","三国志·程普传"},
    {11,4,"曹仁 · 平宛城之乱","侯音起事后，曹仁在219年初攻下宛。","三国志·武帝纪"},
    {15,1,"韩玄 · 长沙太守","曹操取荆州后，黄忠仍属韩玄。","三国志·黄忠传"},
    {16,1,"刘度 · 零陵太守","赤壁战后刘备南征，刘度归降。","三国志·先主传"},
    {17,1,"金旋 · 武陵太守","赤壁战后刘备南征，金旋见于降郡记载。","三国志·先主传"},
    {18,1,"赵范 · 桂阳太守","赤壁战后刘备南征，赵范归降。","三国志·先主传"},
    {19,7,"朱治 · 吴郡太守","据吴后领郡，直至孙吴黄武年间。","三国志·朱治传"},
    {20,7,"王朗 · 曾任会稽太守","孙策取会稽前领郡，早于本战局。","三国志·王朗传"},
    {21,1,"孙贲 · 豫章太守","曹操取荆州时仍领豫章，朱治曾劝其留吴。","三国志·朱治传"},
    {23,1,"刘馥 · 扬州刺史","曾治合肥，同在208年去世。","三国志·刘馥传"},
    {23,4,"张辽 · 曾守合肥","215年与李典、乐进守合肥。","三国志·张辽传"},
    {28,2,"马超 · 曾自号凉州牧","先据冀县，后为杨阜等逐走。冀县在今甘谷。","三国志·马超传"},
    {29,7,"士武 · 曾领南海太守","士燮上表任命，传中未详起讫年。","三国志·士燮传"},
    {30,2,"刘备 · 自葭萌转兵","刘备入蜀后曾驻葭萌，继而攻刘璋。","三国志·先主传"},
    {34,1,"吴巨 · 苍梧太守","刘表遣吴巨继任。步骘入交州后诛吴巨。","三国志·士燮传"},
    {34,6,"步骘 · 交州刺史","210年受孙权委派入交州。郡守姓名未详。","三国志·步骘传"},
    {36,7,"士壹 · 曾领合浦太守","由士燮上表，210年后士氏从孙吴。","三国志·士燮传"},
    {37,7,"士䵋 · 曾任徐闻令","徐闻令在前，后来受表领九真太守。","三国志·士燮传"},
    {38,7,"商升 · 候官长","建安初曾助王朗起兵，早于本战局。","三国志·贺齐传"},
    {39,7,"贺齐 · 在建安立都尉府","203年进兵建安，平定后拜平东校尉。","三国志·贺齐传"},
    {40,7,"士燮 · 交趾太守","多年领交趾，210年遣使从孙吴，仍领郡。","三国志·士燮传"},
    {41,7,"士䵋 · 曾领九真太守","原任徐闻令。九真任职起讫未详。","三国志·士燮传"},
    {43,7,"后载孙权 · 迁治鄂县","发生在221年，改鄂县为武昌。","三国志·吴主传"},
    {44,7,"后载郝昭 · 镇陈仓","守陈仓在228年前后，晚于本战局。","三国志·明帝纪注"},
    {45,1,"曹操 · 曾自谯进军","209年曹军从谯沿涡水入淮，进驻合肥。","资治通鉴·卷六十六"},
    {46,7,"早年刘备 · 曾领平原相","早于本战局，所选年份长吏未详。","三国志·先主传"},
    {fancheng,4,"曹仁 · 屯樊","关羽来攻，汉水暴涨。曹仁守城，直至徐晃来援。","三国志·曹仁传"},
    {shangyong,4,"申耽 · 上庸太守","219年归刘备，仍领上庸太守。","三国志·刘封传"},
    {wancheng,2,"朱光 · 庐江太守","孙权攻皖前，朱光在皖屯田。","三国志·吕蒙传"},
    {47,2,"刘循 · 据守雒城","刘璋之子刘循守城，刘备攻雒近一年。","三国志·刘二牧传"},
};
inline const OfficialRecord* recordedOfficial(int city,int chapter) {
    for (const auto& record:officials)
        if (record.city==city && (record.chapters&(1u<<chapter))) return &record;
    return nullptr;
}

struct Era {
    int year, season;
    const char* name;
};
inline constexpr Era hanEras[]={{196,0,"建安"},{220,1,"延康"}};
inline constexpr Era shuEras[]={{221,1,"章武"},{223,1,"建兴"},{238,0,"延熙"}};
inline constexpr Era weiEras[]={{220,3,"黄初"},{227,0,"太和"},{233,0,"青龙"},{237,1,"景初"},{240,0,"正始"}};
inline constexpr Era wuEras[]={{220,3,"黄初"},{222,0,"黄武"},{229,1,"黄龙"},{232,0,"嘉禾"},{238,2,"赤乌"}};
template<size_t N>
constexpr const Era* eraAt(const Era (&eras)[N],int year,int season) {
    const Era* era=nullptr;
    for (const auto& change:eras)
        if (reachedDate(year,season,change.year,change.season)) era=&change;
    return era;
}
constexpr const Era* historicalEra(int side,int year,int season) {
    // Where a reform falls at the end of a season, use the next playable season.
    if (!reachedDate(year,season,220,3)) return eraAt(hanEras,year,season);
    if (side==0) return eraAt(shuEras,year,season);
    if (side==1) return eraAt(weiEras,year,season);
    return eraAt(wuEras,year,season);
}

struct ChronicleDeed {
    int bit=0, gold=0, grain=0, gainGrain=0, gainOrder=0;
    const char* label=nullptr;
    const char* terms=nullptr;
};
constexpr unsigned deedMask=7;
struct ChronicleEntry {
    int year, season, city;
    const char* title;
    const char* source;
    const char* body;
    ChronicleDeed deed{};
};
inline constexpr ChronicleEntry chronicle[]={
    {208,3,51,"借东风","三国演义·第四十九回","孔明在七星坛祭风。东南风起，黄盖乘火船顺风而下。这是小说写赤壁火攻的情节。"},
    {208,3,51,"赤壁火攻","三国志·周瑜传","周瑜、程普迎战。黄盖献火攻之计，诈降后借风纵火，曹军退回北方。"},
    {212,0,8,"秣陵改建业","三国志·吴主传","孙权移治秣陵，次年筑石头城，改称建业。地图上的城址也随之北移。"},
    {213,0,ruxu,"濡须拒曹","三国志·吴主传","曹操于正月进兵濡须。孙权依水道相拒，双方相持一月有余，曹操引军退去。"},
    {214,1,47,"雒城告破","三国志·先主传","刘备围雒近一年，刘循守城。庞统在围攻中中箭身亡，夏季雒城破。"},
    {214,1,wancheng,"攻取皖城","三国志·吴主传","孙权攻陷皖城，曹军太守朱光被俘。吕蒙、甘宁在攻城中立功。"},
    {215,2,23,"合肥退兵","三国志·张辽传","孙权围合肥。张辽率敢战之士出城突击，吴军未克，退兵时又在津北遇袭。"},
    {219,2,shangyong,"两军会于上庸","三国志·刘封传","孟达从秭归经房陵进兵，刘封自汉中沿沔水东下，申耽举众归附。",
     {1,35,0,0,12,"访山谷乡老","35金 · 民心+12"}},
    {219,2,fancheng,"汉水暴涨","三国志·关羽传","关羽围曹仁于樊城。秋雨使汉水暴涨，于禁所部被淹，于禁降，庞德被俘。"},
    {219,3,7,"白衣渡江","三国演义·第七十五回","吕蒙令士卒装作商人，乘船过江，先控制沿江守哨，再取荆州。"},
    {220,3,1,"汉魏易代","后汉书·献帝纪","汉献帝在三月改元延康，冬季禅位于曹丕。魏改元黄初，随后定都洛阳。"},
    {221,1,2,"成都称帝","三国志·先主传","刘备在成都称帝，国号汉，改元章武。后世通常称蜀汉，以别于东汉。"},
    {221,1,43,"迁鄂改武昌","三国志·吴主传","孙权自公安迁治鄂县，改名武昌。此城在今湖北鄂州。"},
    {222,1,52,"鱼复改永安","三国志·先主传","刘备从猇亭退至秭归，整合离散兵众，随后由步道退到鱼复，改名永安。",
     {2,0,45,0,16,"安置峡江百姓","45粮 · 民心+16"}},
    {223,1,52,"白帝城托孤","三国演义·第八十五回","小说写刘备病重于永安宫，召诸葛亮等托付后事，嘱刘禅以父事丞相。"},
    {228,0,qishan,"初出祁山","三国志·后主传","诸葛亮出兵祁山。街亭失守后，蜀军回撤汉中。同年冬又围陈仓。",
     {4,65,0,140,0,"设陇右粮站","65金 · 粮+140"}},
    {229,2,8,"还都建业","三国志·吴主传","孙权在武昌称帝、改元黄龙。同年九月迁都建业，仍用旧有馆舍。"},
};
constexpr int chronicleCount=int(std::size(chronicle));
inline int latestChronicle(int year,int season,int city=-1) {
    for (int i=chronicleCount-1;i>=0;--i)
        if ((city<0 || chronicle[i].city==city) &&
            reachedDate(year,season,chronicle[i].year,chronicle[i].season)) return i;
    return -1;
}

struct LocalFinds {
    Gear item=noGear;
    int itemChance=0;
    int talentChance=30;
};
constexpr LocalFinds localFinds(int city) {
    switch (city) {
        case 6:return {featherFan,13,56}; // 隆中，演义第三十七回
        case 7:return {dragonBlade,13,34}; // 关羽镇荆州，兵器取演义
        case 10:return {whiteHorse,15,35}; // 的卢旧事见演义第三十四回
        case 2:return {twinJian,14,42};
        case 4:return {manual,20,41};
        case 5:case 24:return {redHare,12,34}; // 下邳旧部、曹营赠马
        case 15:return {featherBow,20,29};
        case 17:return {manual,15,48};
        case 20:case 39:return {featherBow,17,37};
        case 28:return {saddle,23,25};
        case 30:case fucheng:return {manual,19,47};
        case 47:return {featherBow,17,35};
        case 51:return {scaleArmor,16,32};
        case ruxu:return {brightArmor,16,32}; // 魏文帝送明光铠，见吴主传
        case 52:case zigui:return {manual,17,40};
        case 53:case fancheng:return {dragonBlade,11,34};
        case 44:case qishan:return {manual,21,28};
        case shangyong:return {armor,17,37};
        case wancheng:return {scaleArmor,14,31};
        case linzi:return {sword,22,36};
        default:return {};
    }
}
}
