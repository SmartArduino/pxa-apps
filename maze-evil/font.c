#include "font.h"

/* Each glyph is 7 rows of 5 bits, MSB first. Port of maze-evil gfx/font.cpp. */
typedef struct {
    char symbol;
    uint8_t rows[GLYPH_HEIGHT];
} glyph_t;

static const glyph_t kGlyphs[] = {
    {'0', {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E}},
    {'1', {0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E}},
    {'2', {0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F}},
    {'3', {0x1F, 0x02, 0x04, 0x02, 0x01, 0x11, 0x0E}},
    {'4', {0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02}},
    {'5', {0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E}},
    {'6', {0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E}},
    {'7', {0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08}},
    {'8', {0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E}},
    {'9', {0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C}},
    {'A', {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}},
    {'B', {0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E}},
    {'C', {0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E}},
    {'D', {0x1C, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1C}},
    {'E', {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F}},
    {'F', {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10}},
    {'G', {0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F}},
    {'H', {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}},
    {'I', {0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E}},
    {'J', {0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0C}},
    {'K', {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11}},
    {'L', {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F}},
    {'M', {0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11}},
    {'N', {0x11, 0x11, 0x19, 0x15, 0x13, 0x11, 0x11}},
    {'O', {0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}},
    {'P', {0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10}},
    {'Q', {0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D}},
    {'R', {0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11}},
    {'S', {0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E}},
    {'T', {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04}},
    {'U', {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}},
    {'V', {0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04}},
    {'W', {0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A}},
    {'X', {0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11}},
    {'Y', {0x11, 0x11, 0x11, 0x0A, 0x04, 0x04, 0x04}},
    {'Z', {0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F}},
    {'.', {0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C}},
    {':', {0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00}},
    {'/', {0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10}},
    {'-', {0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00}},
    {'%', {0x18, 0x19, 0x02, 0x04, 0x08, 0x13, 0x03}},
    {'!', {0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x04}},
    {'+', {0x00, 0x04, 0x04, 0x1F, 0x04, 0x04, 0x00}},
};

#define GLYPH_COUNT ((int)(sizeof(kGlyphs) / sizeof(kGlyphs[0])))
#define CELLS_PER_ROW (GLYPH_ATLAS_WIDTH / GLYPH_CELL)

static uint8_t g_atlas[GLYPH_ATLAS_WIDTH * GLYPH_ATLAS_HEIGHT];
static sprite_t g_atlas_sprite = {g_atlas, GLYPH_ATLAS_WIDTH,
                                  GLYPH_ATLAS_HEIGHT, GLYPH_ATLAS_WIDTH,
                                  GLYPH_ATLAS_HEIGHT};

static int glyph_index(char symbol) {
    int index;
    if (symbol >= 'a' && symbol <= 'z') {
        symbol = (char)(symbol - 'a' + 'A');
    }
    for (index = 0; index < GLYPH_COUNT; ++index) {
        if (kGlyphs[index].symbol == symbol) {
            return index;
        }
    }
    return -1;
}

void font_build_atlas(void) {
    int index;
    for (index = 0; index < GLYPH_ATLAS_WIDTH * GLYPH_ATLAS_HEIGHT; ++index) {
        g_atlas[index] = 0u;
    }
    for (index = 0; index < GLYPH_COUNT; ++index) {
        const int u0 = (index % CELLS_PER_ROW) * GLYPH_CELL;
        const int v0 = (index / CELLS_PER_ROW) * GLYPH_CELL;
        int row;
        for (row = 0; row < GLYPH_HEIGHT; ++row) {
            const uint8_t bits = kGlyphs[index].rows[row];
            int column;
            for (column = 0; column < GLYPH_WIDTH; ++column) {
                if ((bits & (0x10 >> column)) != 0) {
                    g_atlas[(u0 + column) * GLYPH_ATLAS_HEIGHT + v0 + row] = 1u;
                }
            }
        }
    }
}

const sprite_t *font_atlas(void) { return &g_atlas_sprite; }

int font_glyph_cell(char symbol, int *u0, int *v0) {
    const int index = glyph_index(symbol);
    if (index < 0) {
        return 0;
    }
    *u0 = (index % CELLS_PER_ROW) * GLYPH_CELL;
    *v0 = (index / CELLS_PER_ROW) * GLYPH_CELL;
    return 1;
}

int font_text_width(const char *text, int scale) {
    int length = 0;
    while (text[length] != '\0') {
        ++length;
    }
    return length == 0 ? 0 : (length * (GLYPH_WIDTH + 1) - 1) * scale;
}
